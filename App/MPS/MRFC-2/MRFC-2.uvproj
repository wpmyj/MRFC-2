# Keil uVision project MRFC-2.uvproj, settings and files
target MRFC-2 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MRFC-2--0010-V085-uCos +hex
  c flags: OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,STACK_FAN_PID_CONTROL
  c include: ..\MRFC-2;..\..\..\Board\MPS\HJDHMf-009.1.1\KeilMDK\BSP\OS\uCOS-III;..\..\..\Board\MPS\HJDHMf-009.1.1\KeilMDK\BSP;..\..\..\CPU\ST\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\CPU\ST\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\..\..\uC-CPU;..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\uC-LIB;..\..\..\uCOS-III\Source;..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\uCOS-III\Cfg
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: app.c app_analog_signal_monitor_task.c app_auto_make_vacuum.c app_dc_module_communicate_task.c app_digital_signal_monitor_task.c app_hydrg_producer_manager.c app_mf210_communicate_task.c app_stack_manager.c app_stack_short_circuit_task.c app_system_real_time_parameters.c app_system_run_cfg_parameters.c app_top_task.c app_wireness_communicate_task.c
  group BSP
    ../../../Board/MPS/HJDHMf-009.1.1/KeilMDK/BSP/: bsp.c bsp_ana_sensor.c bsp_atmel_25256b_sshl.c bsp_can.c bsp_dc_module_adjust.c bsp_i2c.c bsp_int.c bsp_MF210.c bsp_ntc.c bsp_periph.c bsp_pid.c bsp_scale_data_read.c bsp_ser.c bsp_speed_adjust_device.c bsp_spi.c
    ../../../Board/MPS/HJDHMf-009.1.1/KeilMDK/BSP/KeilMDK/: cstartup.s
    ../../../Board/MPS/HJDHMf-009.1.1/KeilMDK/BSP/OS/uCOS-III/: bsp_os.c
  group uC/CPU
    ../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ../../../uC-CPU/: cpu_core.c
  group uC/LIB
    ../../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group CPU/LIB STM32F1xx Library
    ../../../CPU/ST/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../../../CPU/ST/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group uC/OS-III Cfg
    ../../../uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
